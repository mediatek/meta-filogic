FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append += "file://0001-rdkb-support-netfilter-netlink-ftnl-tools.patch"
