#EXTRA_OECONF += "--with-json --with-mini-gmp --without-cli"
PACKAGECONFIG = "python json mini-gmp"
