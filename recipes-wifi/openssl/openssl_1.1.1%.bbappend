#add rc4 support for the security mode of wifi is PSK + TKIP
EXTRA_OECONF:remove += "no-rc4"




