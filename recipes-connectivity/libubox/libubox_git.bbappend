SRC_URI_remove = "file://0001-blobmsg-fix-array-out-of-bounds-GCC-10-warning.patch"

SRCREV = "ea56013409d5823001b47a9bba6f74055a6d76a5"
